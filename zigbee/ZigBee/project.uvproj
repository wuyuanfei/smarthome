# Keil uVision project project.uvproj, settings and files
target ZigBee_Prj (ARM-ADS)
  device: LPC11C14x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ZigBee_Prj +hex
  c flags: Optim=1
  c include: ..\Lib_MCU\inc;..\Lib_BSP\inc;.\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group System
    ../Lib_MCU/src/: startup_LPC11xx.s core_cm0.c system_LPC11xx.c
  group Peripheral
    ../Lib_MCU/src/: gpio.c uart.c retarget.c ssp.c i2c.c timer32.c clkconfig.c
  group Board
    ../Lib_BSP/src/: tools.c oled2864.c spi_uart.c key.c light.c temp_hum.c acc.c seg7led.c
  group User
    ./src/: main.c lpc11c14_it.c
    ./: my_functions.c
